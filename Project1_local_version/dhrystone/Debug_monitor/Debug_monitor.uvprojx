# Keil uVision project Debug_monitor.uvprojx, settings and files
target Debug_monitor (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: CPUTYPE("Cortex-M0+")
  output: Debug_monitor
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: MBED_TRAP_ERRORS_ENABLED=1 DEVICE_SLEEP=1 DEVICE_STDIO_MESSAGES=1 TARGET_LIKE_MBED TARGET_M0P DEVICE_SEMIHOST=1 TARGET_CORTEX_M TOOLCHAIN_ARM_STD DEVICE_SERIAL=1 TARGET_KL25Z DEVICE_PORTINOUT=1 DEVICE_USTICKER=1 MBED_RAM_SIZE=0x4000 MBED_BUILD_TIMESTAMP=1632111755.2026126 MBED_MINIMAL_PRINTF __ASSERT_MSG TARGET_FF_ARDUINO __CORTEX_M0PLUS TARGET_NAME=KL25Z DEVICE_INTERRUPTIN=1 DEVICE_ANALOGIN=1 DEVICE_PORTOUT=1 DEVICE_I2C=1 TOOLCHAIN_ARM __MBED_CMSIS_RTOS_CM MULADDC_CANNOT_USE_R7 TARGET_RELEASE MBED_ROM_START=0x0 TOOLCHAIN_ARMC6 __CMSIS_RTOS DEVICE_SPI=1 MBED_ROM_SIZE=0x20000 DEVICE_PORTIN=1 ARM_MATH_CM0PLUS TARGET_CORTEX __MBED__=1 TARGET_Freescale TARGET_KLXX DEVICE_ANALOGOUT=1 DEVICE_SPISLAVE=1 MBED_RAM_START=0x1ffff000 DEVICE_I2CSLAVE=1 DEVICE_PWMOUT=1 TARGET_LIKE_CORTEX_M0
  c misc: --no_rtti --cpu=Cortex-M0plus -c --split_sections --no_depend_system_headers --md --gnu --apcs=interwork --preinclude=mbed_config.h
  c include: ;/usr/src/mbed-sdk;mbed;mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD;mbed/drivers;mbed/hal;mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__MBED_CMSIS_RTOS_CM,-DARM_MATH_CM0PLUS,-D__CMSIS_RTOS,-D__CORTEX_M0PLUS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/MKL25Z4.sct
  link misc: --legacyalign --any_contingency --keep=os_cb_sections --predefine="-DMBED_ROM_SIZE=0x20000" --predefine="-DMBED_RAM_START=0x1ffff000" --predefine="-DXIP_ENABLE=0" --inline --predefine="-DMBED_BOOT_STACK_SIZE=4096" --show_full_path --predefine="-DMBED_ROM_START=0x0" --predefine="-DMBED_RAM_SIZE=0x4000" --cpu=Cortex-M0plus
  group Debug_monitor
    ./: main.cpp mbed_config.h Monitor.cpp shared.h timer0.cpp UART_poll.cpp
    ./: dhry_1.c dhry_2.c dhry.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RawSerial.h Serial.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h TableCRC.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h Driver_Common.h Driver_Storage.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.h lp_ticker_api.h mbed_lp_ticker_wrapper.h pinmap.h port_api.h pwmout_api.h qspi_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o arm_math.h clk_freqs.h cmsis.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_nvic.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h device.h gpio_api.o gpio_irq_api.o gpio_object.h i2c_api.o mbed.ar mbed_board.o mbed_cmsis_conf.h mbed_overrides.o mbed_retarget.o mbed_rtx.h mbed_sdk_boot.o mbed_tz_context.o MKL25Z4.h mpu_armv7.h mpu_armv8.h objects.h PeripheralNames.h PeripheralPins.h PeripheralPins.o pinmap.o PinNames.h port_api.o PortNames.h pwmout_api.o rtc_api.o RTE_Components.h serial_api.o sleep.o spi_api.o startup_MKL25Z4.o system_MKL25Z4.h system_MKL25Z4.o tz_context.h us_ticker.o
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_error_hist.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_version.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h semihost_api.h SharedPtr.h SingletonPtr.h sleep.h Span.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/: mbed.h
